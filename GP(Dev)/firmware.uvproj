# Keil uVision project firmware.uvproj, settings and files
target 1887ВЕ3Т (166/167)
  device: 1887VE3T Generic
  cpu: IRAM(0xF600-0xFDFF) XRAM(0xD800-0xE7FF) IROM(0x000000-0x07FFF) IROM2(0x018000-0x04FFFF) CLOCK(20000000) MOD167
  output: BDGP_FRM +hex
  group ProjectFiles
    ./: START_V2.A66 asmbsl.a66 driver.a66 main.c process.c debug.c
  group Protocol
    ./: protocol.c
  group Drivers
    ./: can.c settings.c flash.c system.c
  group Notes
    ./: Notes.txt
